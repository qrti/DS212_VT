# IAR project DS212.ewp, settings and files
configuration DS212 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; APP_MODE
  ICCARM.CCIncludePath2: Inc; Src; ..\Libraries\CMSIS\Device\STM32F30x\Include; ..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DS212APP.hex
  ILINK.IlinkOutputFile: ALL.out
  ILINK.IlinkIcfFile: DS212.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    Src/: DFU_Bios.s Disk.c Display.s Draw.c Drive.c FAT12.c Files.c Flash.c Func.c Interrupt.c LCD.c Main.c Process.c
  group CMSIS
    Src/: Startup.s
    ../Libraries/CMSIS/Device/STM32F30x/Source/: system_stm32f30x.c
  group MSD
    Src/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group STM32_USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F30x_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
